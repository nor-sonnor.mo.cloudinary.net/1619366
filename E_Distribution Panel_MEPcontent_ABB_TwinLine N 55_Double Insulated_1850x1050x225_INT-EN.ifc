Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-09-18T17:15:15
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Sep 18 17:15:15 2018 * Host: B3ROBRAWR4428 * Database: C:\Users\LFrancu\AppData\Local\Temp\{BB5628C5-1309-4F90-8E48-FDB697945649}\ifc * Database version: 5507 * Database creation date: Tue Sep 18 17:15:13 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue Sep 18 17:15:13 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Sep 18 17:15:13 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Dimensions - Computation Height: 0 mm

# IfcElectricDistributionBoard: 1850x1050x225, E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_INT-EN:1850x1050x225:1307663
In: V00
Type - PredefinedType: DISTRIBUTIONBOARD; Material: Color RGB 040-040-040, Color RAL 7035
Type - Dimensions - Depth: 225 mm; Height: 1850 mm; Width: 1050 mm
Type - Electrical - Hertz: 0 Hz
Type - Electrical - Loads - Power: 0 W
Type - General - Protection Class: Double Insulated
Type - Identity Data - Base Family Version: 11.18; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Wall-mounting and floor-standing cabinets IP55; EMCS Version: 4.0; ETIM Article Class: EC000058; Family Version: 11.19; Manufacturer: ABB; Manufacturer URL: https://new.abb.com/low-voltage/products/system-pro-e/system-pro-e-energy/twinline-n; MEPcontent Class: DISTRIBUTION_PANEL; Model: 1850x1050x225; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Revit Version: 2018; Type Name: 1850x1050x225; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Glass: Color RGB 236-240-239; Light Grey: Color RGB 180-180-180; White: Color RAL 7035
Type - Other - Category: Electrical Equipment; Blind Door: Door: Blind Door; Cabinet Thickness: 10 mm; Door Angle: 90 deg; Door Split Void: 10 mm; Door Split Void Position: 518.5 mm; Eyebolts Offset: 16 mm; Eyebolts Offset 2: 35.5 mm; Family Name: E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_INT-EN; Front Mounted: yes; Glass Door: Door: Glass Door; Half Depth: 112.5 mm; Handle Offset: 573.5 mm; Hinges Position: 0 mm; Lookup Table 1: Parameters_ABB TwinLine N55_External Dimensions; Lookup Table 2: Parameters_ABB TwinLine N55_Internal Dimensions; Lookup Table 3: Parameters_ABB TwinLine N55_Article Type; Lookup Table 4: Parameters_ABB TwinLine N55_Article Number; Lookup Table 5: Parameters_ABB TwinLine N55_GTIN; No Door: No: Door; No Plinth1: Plinth: No Plinth; No Plinth2: Plinth: No Plinth; No Plinth3: Plinth: No Plinth; Plinth 100mm1: Plinth: Plinth 100 mm; Plinth 100mm2: Plinth: Plinth 100 mm; Plinth 100mm3: Plinth: Plinth 100 mm; Plinth 50mm1: Plinth: Plinth 50 mm; Plinth 50mm2: Plinth: Plinth 50 mm; Plinth 50mm3: Plinth: Plinth 50 mm; Plinth Depth: 203.5 mm; Protection Class Condition: yes; Service Area Depth: 531.5 mm; Side Panels Offset: 0 mm; Top Panel Offset: 10 mm; Type Number: 94; Wall Fastening Offset 1: 0 mm; Wall Fastening Offset 2: 10 mm; Wall Fastening Offset 3: 0 mm; Wall Fastening Offset 4: 0 mm; Wall Fastening Offset 5: 5 mm; Wall Fastenings Visible: yes; Wall Mounted: no
Type - Text - Product Line: ABB
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 11.2671 m2; External Dimensions: 1850x1050; Internal Dimensions: 1802x1002; Volume: 2.13577 m3
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Total Connected: 0 W; Total Demand Factor: 1; Total Estimated Demand: 0 W
General - Degree of Protection: IP55
Identity Data - Article Type: TG412S; Design Option: Main Model; Mark: 2
Other - Blind Door Condition: 1; Blind Door Visible: yes; Blind or Glass Door Visible: 1; Cabinet Depth Offset: 12 mm; Cabinet Offset: 100 mm; Door Visible: no; Door Visible 2: yes; Family: E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_INT-EN: 1850x1050x225; Family and Type: E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_INT-EN: 1850x1050x225; Glass Door Condition: 0; Glass Door Visible: no; Hinges Visibility Left: yes; Hinges Visibility Right: yes; Logo Left Visible: no; Logo Right Visible: no; No Door Condition: 0; No Door Visible: no; No Plinth 1: no; No Plinth 2: yes; No Plinth 3: yes; Plinth 100mm 1: yes; Plinth 100mm 2: no; Plinth 100mm 3: no; Plinth 1 Height: 100 mm; Plinth 1 Offset: 100 mm; Plinth 2 Height: 50 mm; Plinth 2 Offset: 100 mm; Plinth 3 Height: 50 mm; Plinth 3 Offset: 100 mm; Plinth 50mm 1: no; Plinth 50mm 2: no; Plinth 50mm 3: no; Plinth Hole Offset: 50 mm; Plinth Info 1 Visible: yes; Plinth Info 2 Visible: no; Plinth Info 3 Visible: no; Plinth Side Position: 0 mm; Second Door: yes; Service Area Safe: no; Service Area Width Left: 1043.5 mm; Service Area Width Right: 1056.5 mm; Type: E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_INT-EN: 1850x1050x225; Type Id: E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_INT-EN: 1850x1050x225
Phasing - Phase Created: 3. Nieuwbouw
Text - Article Description: Floor-standing cabinet IP55, double insulated; GTIN: 4011617100683; Manufacturer Art. No.: 2CPX010068R9999
Visibility - Door: Door: Blind Door; Eyebolts: no; Flange Openings on Bottom: yes; Flange Openings on Top: no; Horizontal Wall Fastenings: no; Plinth 1: Plinth: Plinth 100 mm; Plinth 2: Plinth: No Plinth; Plinth 3: Plinth: No Plinth; Reverse Door Opening: no; Service Area: no

# IfcElectricDistributionBoard: Plinth 100 mm, Plinth:Plinth 100 mm:1307670
In: V00
Type - PredefinedType: DISTRIBUTIONBOARD; Material: Color RAL 9005
Type - Identity Data - Custom: no; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Description: Plinth; EMCS Version: 3.0; ETIM Article Class: EC000721; Family Version: 11.17; Manufacturer: ABB; MEPcontent Class: DISTRIBUTION_PANEL; Model: Plinth; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Revit Version: 2018; Type Name: Plinth 100 mm; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Dark Black: Color RAL 9005
Type - Other - Category: Data Devices; Family Name: Plinth
Type - Text - Product Line: ABB
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.31031 m2; Depth: 225 mm; Depth 2: 203.5 mm; Height: 100 mm; Volume: 0.007161 m3; Width: 1050 mm
Identity Data - Article Type: TZG410; Design Option: Main Model; Mark: 2
Other - Wall Mounted: no; Family: Plinth: Plinth 100 mm; Family and Type: Plinth: Plinth 100 mm; Number: 1; Plinth 50 mm Safe: no; Plinth Hole Offset: 50 mm; Type: Plinth: Plinth 100 mm; Type Id: Plinth: Plinth 100 mm; Void Offset 1: 0 mm; Void Offset 2: 151.75 mm
Phasing - Phase Created: 3. Nieuwbouw
Text - Article Description: Plinth 100 mm; GTIN: 4011617105787; Manufacturer Art. No.: 2CPX010578R9999
Visibility - No Plinth: no; Plinth 100 mm: yes; Plinth 50 mm: no
