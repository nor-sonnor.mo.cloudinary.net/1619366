Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2023-06-23T10:44:43
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.0.0.383 - Exporter 21.2.1.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 23 10:44:43 2023 * Host: LCULICA-RO-LE * Database: C:\Users\lculica\AppData\Local\Temp\57884ca7-2c98-4304-a922-3d9874019a52\70899317-2b97-492c-bee4-221e11029311\ifc * Database version: 5507 * Database creation date: Fri Jun 23 10:44:42 2023 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Jun 23 10:44:42 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 23 10:44:42 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level

# IfcElectricDistributionBoard: E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_400_INT-EN:1850x800x400, E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_400_INT-EN:1850x800x400:1364337
In: F00
Type - PredefinedType: DISTRIBUTIONBOARD; Material: Color RGB 040-040-040, Color RAL 7035 (2)
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 400 mm; Height: 1850 mm; Width: 800 mm
Type - Electrical - Hertz: 0 Hz
Type - Electrical - Loads - Power: 0 W
Type - General - Protection Class: Earthed
Type - Identity Data - Article Description: Floor-standing cabinet IP55, double insulated; Article Type: TX312S; Base Family Version: 23.07; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Floor-standing cabinet IP55, double insulated; EMCS Version: 4.0; ETIM Article Class: EC000058; Family Version: 12.26; GTIN: 4011617109785; Manufacturer: ABB; Manufacturer Art. No.: 2CPX010978R9999; Manufacturer URL: https://new.abb.com/low-voltage/products/system-pro-e/system-pro-e-energy/twinline-n; MEPcontent Class: DISTRIBUTION_PANEL; Model: 1850x800x400; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: ABB; Revit Version: 2021; Type Name: 1850x800x400; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Glass: Color RGB 236-240-239; Light Grey: Color RGB 180-180-180; White: Color RAL 7035
Type - Other - Category: Electrical Equipment; Blind Door: Door: Blind Door; Cabinet Thickness: 10 mm; Door Angle: 90 deg; Door Split Void: 0 mm; Door Split Void Position: 400 mm; Eyebolts Offset: 16 mm; Eyebolts Offset 2: 35.5 mm; Family Name: E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_400_INT-EN; Front Mounted: yes; Glass Door: Door: Glass Door; Half Depth: 200 mm; Handle Offset: 55 mm; Hinges Position: 0 mm; Lookup Table 1: Parameters_ABB TwinLine N55_External Dimensions; Lookup Table 2: Parameters_ABB TwinLine N55_Internal Dimensions; Lookup Table 3: Parameters_ABB TwinLine N55_Article Type1; Lookup Table 4: Parameters_ABB TwinLine N55_Article Number1; Lookup Table 5: Parameters_ABB TwinLine N55_GTIN1; No Door: No: Door; No Plinth1: Plinth 400S: No Plinth; No Plinth2: Plinth 400S: No Plinth; No Plinth3: Plinth 400S: No Plinth; Plinth 100mm1: Plinth 400S: Plinth 100 mm; Plinth 100mm2: Plinth 400S: Plinth 100 mm; Plinth 100mm3: Plinth 400S: Plinth 100 mm; Plinth 50mm1: Plinth 400S: Plinth 50 mm; Plinth 50mm2: Plinth 400S: Plinth 50 mm; Plinth 50mm3: Plinth 400S: Plinth 50 mm; Plinth Depth: 378.5 mm; Protection Class Condition: no; Service Area Depth: 800 mm; Side Panels Offset: 0 mm; Top Panel Offset: 10 mm; Type Number: 98; Wall Fastening Offset 1: 0 mm; Wall Fastening Offset 2: 10 mm; Wall Fastening Offset 3: 0 mm; Wall Fastening Offset 4: 0 mm; Wall Fastening Offset 5: 5 mm; Wall Fastenings Visible: yes; Wall Mounted: no
Type - Visibility - Door: Door: Blind Door; Horizontal Wall Fastenings: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB
Material: Color RGB 040-040-040, Color RAL 7035
Pset_ElectricDistributionBoardTypeCommon - Reference: 1850x800x400; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 11.3883 m2; External Dimensions: 1850x800; Internal Dimensions: 1802x752; Volume: 0.0558634 m3
Electrical - Circuiting - Circuit Numbering Option: Default; Feed Through Lugs: yes; MCB Rating: 1 A; SubFeed Lugs: yes
Electrical - Loads - Apparent Load Phase A: 0 W; Apparent Load Phase B: 0 W; Apparent Load Phase C: 0 W; Branch Circuit Apparent Load Phase A: 0 W; Branch Circuit Apparent Load Phase B: 0 W; Branch Circuit Apparent Load Phase C: 0 W; Feed Through Lugs Apparent Load Phase A: 0 W; Feed Through Lugs Apparent Load Phase B: 0 W; Feed Through Lugs Apparent Load Phase C: 0 W; Total Connected: 0 W; Total Demand Factor: 100; Total Estimated Demand: 0 W
General - Degree of Protection: IP55
Identity Data - Mark: 2
Other - Blind Door Condition: 1; Blind Door Visible: yes; Blind or Glass Door Visible: 1; Cabinet Depth Offset: 12 mm; Cabinet Offset: 50 mm; Door Visible: no; Door Visible 2: yes; Family: E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_400_INT-EN: 1850x800x400; Family and Type: E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_400_INT-EN: 1850x800x400; Glass Door Condition: 0; Glass Door Visible: no; Hinges Visibility Left: yes; Hinges Visibility Right: no; Logo Left Visible: no; Logo Right Visible: no; No Door Condition: 0; No Door Visible: no; No Plinth 1: no; No Plinth 2: yes; No Plinth 3: yes; Plinth 100mm 1: no; Plinth 100mm 2: no; Plinth 100mm 3: no; Plinth 1 Height: 50 mm; Plinth 1 Offset: 50 mm; Plinth 2 Height: 50 mm; Plinth 2 Offset: 50 mm; Plinth 3 Height: 50 mm; Plinth 3 Offset: 50 mm; Plinth 50mm 1: yes; Plinth 50mm 2: no; Plinth 50mm 3: no; Plinth Hole Offset: 160 mm; Plinth Info 1 Visible: yes; Plinth Info 2 Visible: no; Plinth Info 3 Visible: no; Plinth Side Position: 0 mm; Second Door: no; Service Area Safe: no; Service Area Width Left: 400 mm; Service Area Width Right: 1200 mm; Type: E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_400_INT-EN: 1850x800x400; Type Id: E_Distribution Panel_MEPcontent_ABB_TwinLine N 55_Double Insulated_400_INT-EN: 1850x800x400
Phasing - Phase Created: 3. New Construction
Visibility - Eyebolts: no; Flange Openings on Bottom: no; Flange Openings on Top: yes; Left Side Panel: no; Plinth 1: Plinth 400S: No Plinth; Plinth 2: Plinth 400S: No Plinth; Plinth 3: Plinth 400S: No Plinth; Reverse Door Opening: no; Right Side Panel: no; Service Area: no; Support Panel Left: yes; Support Panel Right: yes

# IfcElectricDistributionBoard: Plinth 400S:No Plinth, Plinth 400S:No Plinth:1364346
In: F00
Type - PredefinedType: DISTRIBUTIONBOARD; Material: Color RAL 9005
Type - Constraints - Default Elevation: 0 mm
Type - Identity Data - Custom: no; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Description: Plinth; EMCS Version: 4.0; ETIM Article Class: EC000721; Family Version: 12.26; Manufacturer: ABB; MEPcontent Class: DISTRIBUTION_PANEL; Model: Plinth; OmniClass Number: 23.80.30.11.17; OmniClass Title: Distribution Boards and Control Panels; Product Line: ABB; Revit Version: 2017; Type Name: No Plinth; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Dark Black: Color RAL 9005
Type - Other - Category: Data Devices; Family Name: Plinth 400S
Type - Pset_ManufacturerTypeInformation - Manufacturer: ABB
Pset_ElectricDistributionBoardTypeCommon - Reference: No Plinth; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.22976 m2; Depth: 378.5 mm; Depth 2: 378.5 mm; Height: 50 mm; Volume: 0.0040955 m3; Width: 800 mm
Identity Data - Article Description: Plinth 50 mm; Article Type: TX312S; GTIN: 4011617109822; Manufacturer Art. No.: 2CPX010982R9999; Mark: 2
Other - Wall Mounted: no; Family: Plinth 400S: No Plinth; Family and Type: Plinth 400S: No Plinth; Number: 1; Plinth 50 mm Safe: yes; Plinth Hole Offset: 160 mm; Type: Plinth 400S: No Plinth; Type Id: Plinth 400S: No Plinth; Void Offset 1: 0 mm; Void Offset 2: 239.25 mm
Phasing - Phase Created: 3. New Construction
Visibility - No Plinth: no; Plinth 100 mm: no; Plinth 50 mm: yes
